# For displaying console output on both UART and HDMI
CMDLINE_append = " console=serial0,115200 console=tty1"
